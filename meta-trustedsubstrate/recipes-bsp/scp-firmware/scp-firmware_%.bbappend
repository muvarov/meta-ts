MACHINE_SCP_REQUIRE ?= ""

MACHINE_SCP_REQUIRE:synquacer = "scp-firmware-synquacer.inc"

require ${MACHINE_SCP_REQUIRE}
