COMPATIBLE_MACHINE:ledge-synquacer = "ledge-synquacer"
COMPATIBLE_MACHINE:ledge-rockpi4b = "ledge-rockpi4b"
